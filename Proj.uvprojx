# Keil uVision project Proj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB
  c include: .\Driver\CMSIS;.\Driver\Device;.\Driver\HAL\Inc;.\Driver\HAL\Inc\Legacy;.\Driver\HAL;.\User\Inc;.\ThridParty\RT-Thread\include;.\ThridParty\RT-Thread\port;.\ThridParty\RT-Thread\libcpu;.\Hardware;.\BMSCore;.\Tests\afe_board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Driver/CMSIS
    ./Driver/CMSIS/: cmsis_armcc.h core_cm3.h core_cmInstr.h core_cmFunc.h
  group Driver/Device
    ./Driver/Device/: stm32f1xx.h stm32f103xb.h system_stm32f1xx.c system_stm32f1xx.h
    ./Driver/: startup_stm32f103xb.s
  group Driver/HAL/Src
    ./Driver/HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Driver/HAL/Inc
    ./Driver/HAL/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_usb.h
    ./Driver/HAL/Inc/Legacy/: stm32_hal_legacy.h
    ./User/Inc/: stm32f1xx_it.h
  group Driver/HAL/Conf
    ./Driver/HAL/: stm32f1xx_hal_conf.h
  group User/Src
    ./User/Src/: main.c stm32f1xx_it.c sys.c dwt.c
  group User/Inc
    ./User/Inc/: main.h sys.h dwt.h
  group ThridParty/RT-Thread/Src
    ./ThridParty/RT-Thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group ThridParty/RT-Thread/Inc
    ./ThridParty/RT-Thread/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtm.h rtservice.h rtthread.h
  group ThridParty/RT-Thread/libcpu
    ./ThridParty/RT-Thread/libcpu/: context_rvds.S cpuport.c
  group ThridParty/RT-Thread/port
    ./ThridParty/RT-Thread/port/: board.c rtconfig.h board.h
  group Hardware
    ./Hardware/: i2c_driver.c i2c_driver.h bq76920_driver.c bq76920_driver.h
  group BMSCore
    ./BMSCore/: AFE_Core.c AFE_Core.h
  group Tests/AFE Board
    ./Tests/afe_board/: AFE_Test.c AFE_Test.h
